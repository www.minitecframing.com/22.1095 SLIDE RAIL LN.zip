# Autodesk Inventor assembly: 22.1095 SLIDE RAIL LN
## iProperties
Created: 2007-06
Part Number: 22.1095 SLIDE RAIL LN
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
